# IAR project game-qk.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LM3S811 Luminary LM3S811
  ICCARM.CCDefines: ewarm; PART_LM3S811
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; ..\..\..\..\include; $TOOLKIT_DIR$\examples\Luminary\Stellaris; $TOOLKIT_DIR$\examples\Luminary\Stellaris\boards\ek-lm3s811
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: game-qk.bin
  ILINK.IlinkOutputFile: game-qk.out
  ILINK.IlinkIcfFile: lm3s811.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: ewarm; PART_LM3S811; NDEBUG
  group Luminary
    $EW_DIR$/ARM/examples/Luminary/Stellaris/driverlib/ewarm/Exe/: driverlib.a
    $EW_DIR$/ARM/examples/Luminary/Stellaris/boards/ek-lm3s811/: osram96x16x1.c
  group QP-nano
    ../../../../source/: qepn.c qfn.c qkn.c
    ./: qkn_port.s
  group Source
    ./: bsp.c main.c mine1.c mine2.c missile.c ship.c startup.c tunnel.c
